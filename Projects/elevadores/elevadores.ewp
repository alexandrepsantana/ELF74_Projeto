# IAR project elevadores.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: src\UART_Config.h
  ICCARM.CCIncludePath2: ..; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: elevadores.bin
  ILINK.IlinkOutputFile: UART_inst.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../drivers/: driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    ./: RTX_CM.a
    src/: RTX_Config.c RTX_Config.h rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c UART_inst.c
    ../../TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
